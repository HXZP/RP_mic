# Keil uVision project rp_first.uvprojx, settings and files
target rp_first (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: rp_first +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                               ../Middlewares/Third_Party/FreeRTOS/Source/include;                               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                               ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                               ../Drivers/CMSIS/Include;                               ..\Drivers\CMSIS\DSP\Include;                               ..\Drivers\CMSIS\DSP\Source;                               ..\MDK-ARM;                               .\USER\DSP\Include;                               .\USER\Algo;                               .\USER\Config;                               .\USER\Devices;                               .\USER\Drivers;                               .\USER\Function;                               .\USER\Imu;                               .\USER\Module;                               .\USER\motor;                               .\USER\Potocal;                               .\USER\Task;                               .\USER;                               .\rp_first
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group CONFIG
    ./USER/Config/: rp_config.h
    ../: readme.txt
    ./USER/motor/: motor_class.h
  group Application/Task
    ./USER/Task/: led_task.c Imu_task.c Vision_task.c judge_task.c Shoot_task.c Gimbal_task.c Chassis_task.c Normal_task.c
  group Application/Module
    ./USER/Module/: State.c key.c Shoot.c Gimbal.c Chassis.c Super_Ctrl.c Offline_check.c
  group Application/Function
    ./USER/Function/: UI.c Auto.c S_function.c
    ./: Power_Limit.c
  group Application/Config
    ./USER/Config/: rp_init.c rp_sys.h CONFIG.h
  group Application/Potocol
    ./USER/Potocal/: POTOCAL.h can_potocal.c usart_potocal.c soft_iic_potocal.c
  group Application/Device
    ./USER/Devices/: DEVICE.h rc.c imu.c slave.c super.c motor.c cap_protocol.c vision_sensor.c vision_potocol.c judge_sensor.c judge_infantrypotocol.c rp_device.h
  group Application/Device/imu
    ./USER/Imu/: bmi.c bmi2.c bmi270.c bmi2_ois.c bmi2_common.c bmi270_context.c
  group Application/Device/motor
    ./USER/motor/: Chassis_motor.c Gimbal_motor.c Shoot_motor.c
  group Application/Drivers
    ./USER/Drivers/: DRIVE.h io_drv.c soft_iic.c tim_drv.c uart_drv.c can_drv.c adda_drv.c haltick_drv.c rp_driver.h
  group Application/Algo
    ./USER/Algo/: ALGO.h pid.c crc.c kalman.c rp_math.c kalman_filter.c rp_algo.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dac.c dma.c iwdg.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_sub_f32.c arm_mat_add_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mat_inverse_f32.c
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group DSP
    ./USER/DSP/Include/: arm_math.h core_sc000.h core_sc300.h arm_const_structs.h arm_common_tables.h
    ./USER/DSP/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
